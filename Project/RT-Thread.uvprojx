# Keil uVision project RT-Thread.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RT-Thread +hex
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\User;..\CMSIS;..\Library\inc;..\FreeRTOS\include;..\FreeRTOS\port\RVDS\ARM_CM4F;..\MyFiles\delay;..\MyFiles\sys;..\MyFiles\usart;..\MyFiles\led;..\MyFiles\key;..\MyFiles\bit_addr;..\MyFiles\oled
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: main.c stm32f4xx_it.c system_stm32f4xx.c
  group Core
    ../CMSIS/: startup_stm32f40_41xxx.s
  group MyFiles
    ../MyFiles/delay/: delay.c
    ../MyFiles/usart/: usart.c
    ../MyFiles/led/: led.c
    ../MyFiles/key/: key.c
    ../MyFiles/oled/: oled.c
  group Library
    ../Library/src/: stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_rcc.c stm32f4xx_tim.c misc.c stm32f4xx_dma.c stm32f4xx_i2c.c
  group Doc
    ../: readme.txt
software components: RTOS:kernel 3.1.5, RTOS:shell 3.1.5
